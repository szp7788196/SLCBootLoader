# Keil uVision project BootLoader.uvproj, settings and files
target BootLoader (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BootLoader +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\MALLOC;..\JSON;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\PERIPHERAL\iic1;..\DEVICEDRIVER\24cxx;..\DEVICEDRIVER\led;..\PERIPHERAL\usart;..\DEVICEDRIVER\bg96;..\NET;..\DEVICEDRIVER\stmflash;..\PERIPHERAL\rtc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../USER/: main.c common.c stm32f10x_it.c ota.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group PERIPHERAL
    ../PERIPHERAL/iic1/: iic1.c
    ../PERIPHERAL/usart/: usart.c
    ../PERIPHERAL/rtc/: rtc.c
  group DEVICEDRIVER
    ../DEVICEDRIVER/24cxx/: 24cxx.c
    ../DEVICEDRIVER/bg96/: bg96.c
    ../DEVICEDRIVER/led/: led.c
    ../DEVICEDRIVER/stmflash/: stmflash.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MALLOC
    ../MALLOC/: malloc.c
  group NET
    ../NET/: ringbuf.c tcp.c http.c
